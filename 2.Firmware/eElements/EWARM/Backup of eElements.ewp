# IAR project Backup of eElements.ewp, settings and files
configuration eElements (ARM, debug)
  General.OGChipSelectEditMenu: STM32L431CC ST STM32L431CC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L431xx
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32L4xx_HAL_Driver/Inc; ../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32L4xx/Include; ../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: eElements.hex
  ILINK.IlinkOutputFile: eElements.out
  ILINK.IlinkIcfFile: stm32l431xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32l431xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c opamp.c spi.c usart.c stm32l4xx_it.c stm32l4xx_hal_msp.c
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_exti.c stm32l4xx_hal_opamp.c stm32l4xx_hal_opamp_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32l4xx.c
